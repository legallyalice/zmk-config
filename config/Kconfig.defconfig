## config/Kconfig.defconfig
```kconfig
if SHIELD_CADPAD

# Name must be less than 16 characters long!

config ZMK_KEYBOARD_NAME
  default "CAD Pad"

endif
```
